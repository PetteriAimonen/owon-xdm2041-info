.title KiCad schematic
U4 Net-_R17-Pad1_ NC_01 VSSA Net-_C9-Pad2_ VSSA NC_02 /VREF_1.25 /PB5 /PB4 Net-_R34-Pad2_ /PB2 NC_03 Net-_C6-Pad1_ Net-_C19-Pad2_ /PB1 /PB0 Net-_R26-Pad2_ /OP1N /OP1O /OP2N /OP2O Net-_C7-Pad1_ Net-_C7-Pad2_ NC_04 VDD NC_05 Net-_U4-Pad27_ Net-_U4-Pad28_ /NSS1 /SCK /MOSI /MISO NC_06 /CNT GNDD NC_07 Net-_C2-Pad1_ Net-_R18-Pad2_ Net-_C41-Pad1_ Net-_R20-Pad2_ Net-_R21-Pad2_ Net-_R22-Pad2_ Net-_C3-Pad1_ Net-_R23-Pad2_ Net-_R24-Pad2_ NC_08 Net-_C3-Pad2_ NC_09 HY3131
U7 Net-_U4-Pad28_ Net-_U4-Pad27_ 4 MHz
U8 GNDPWR Net-_C40-Pad1_ Net-_L3-Pad2_ Net-_L4-Pad2_ NC_10 F0505S-1W
U9 /RL2_CTRL /RL1_CTRL /U2_CTRL NC_11 /U19_CTRL NC_12 NC_13 GNDD NC_14 VDD /SCK /NSS2 GNDD /MOSI /U1_CTRL VDD 74HC595
C05 GNDPWR Net-_C05-Pad2_ 5V in
C06 Net-_C06-Pad1_ 4WR+
C07 Net-_C07-Pad1_ 4WR-
C03 GNDA COM
C02 Net-_C02-Pad1_ A
U1 Net-_R6-Pad2_ Net-_D3-Pad2_ +5V Net-_F1-Pad2_ Net-_F1-Pad2_ Net-_R12-Pad1_ JS1-5V-F
R12 Net-_R12-Pad1_ Net-_R12-Pad2_ GNDA GNDA R_Shunt
U3 Net-_U3-Pad1_ GNDA Net-_R6-Pad2_ Net-_U3-Pad1_ D_Bridge_-AA+
R49 Net-_R49-Pad1_ Net-_R47-Pad1_ 10k
R47 Net-_R47-Pad1_ Net-_R27-Pad1_ 10k
R27 Net-_R27-Pad1_ Net-_R27-Pad2_ 10k
R69 Net-_R27-Pad2_ Net-_R67-Pad1_ 10k
R67 Net-_R67-Pad1_ Net-_C06-Pad1_ 10k
R50 Net-_C25-Pad1_ Net-_R48-Pad1_ 10k
R48 Net-_R48-Pad1_ Net-_R33-Pad1_ 10k
R33 Net-_R33-Pad1_ Net-_R33-Pad2_ 10k
R70 Net-_R33-Pad2_ Net-_R68-Pad1_ 10k
R68 Net-_R68-Pad1_ Net-_C07-Pad1_ 10k
R18 Net-_R14-Pad2_ Net-_R18-Pad2_ 2.5M
R23 Net-_C3-Pad2_ Net-_R23-Pad2_ 10M
R22 Net-_C3-Pad2_ Net-_R22-Pad2_ 1k
R21 Net-_C3-Pad2_ Net-_R21-Pad2_ 10k
R19 Net-_C3-Pad2_ Net-_C41-Pad1_ 1M
R24 Net-_C3-Pad2_ Net-_R24-Pad2_ 1k
U11 Net-_R41-Pad2_ VDD +5V AMS1117
R42 Net-_R41-Pad2_ GNDD 820
R41 VDD Net-_R41-Pad2_ 430
RL1 Net-_D1-Pad2_ NC_15 Net-_C04-Pad1_ Net-_RL1-Pad4_ Net-_RL1-Pad4_ Net-_R5-Pad2_ Net-_R62-Pad2_ VDD UD2-3NU
RL2 Net-_D2-Pad2_ NC_16 Net-_R6-Pad2_ Net-_R6-Pad1_ Net-_R7-Pad2_ Net-_R13-Pad2_ Net-_R6-Pad2_ VDD UD2-3NU
U19 VDD Net-_R60-Pad2_ NC_17 Net-_R76-Pad2_ NC_18 Net-_R2-Pad1_ AA40F
U13 GNDPWR /MCU_NSS2 GNDPWR GNDPWR /VDD_MCU /VDD_MCU NC_19 /MCU_MISO NC_20 /MCU_MOSI NC_21 /MCU_SCK NC_22 /MCU_NSS1 NC_23 NC_24 To MCU board
C04 Net-_C04-Pad1_ V/R
R20 Net-_C3-Pad2_ Net-_R20-Pad2_ 100k
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ C
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 27nF
R45 /CNT Net-_C14-Pad2_ 100
R62 GNDA Net-_R62-Pad2_ 100
R14 Net-_R10-Pad2_ Net-_R14-Pad2_ 2.5M
R10 Net-_R10-Pad1_ Net-_R10-Pad2_ 2.5M
R3 Net-_C04-Pad1_ Net-_R10-Pad1_ 2.5M
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ C
R8 Net-_C2-Pad2_ Net-_C04-Pad1_ 270k
R2 Net-_R2-Pad1_ Net-_C04-Pad1_ 270k
R76 Net-_R76-Pad1_ Net-_R76-Pad2_ 0
R9 Net-_R76-Pad1_ Net-_R11-Pad1_ 270k
R11 Net-_R11-Pad1_ /PB0 20k
C25 Net-_C25-Pad1_ GNDA C
R51 /PB5 Net-_C25-Pad1_ 1k
R52 /PB2 Net-_R49-Pad1_ 1k
C26 /PB2 /PB5 C
R34 GNDA Net-_R34-Pad2_ 1k
F1 Net-_C02-Pad1_ Net-_F1-Pad2_ Fuse
R28 /OP1O /OP1N 90k
R30 GNDA /OP1N 10k
R26 GNDA Net-_R26-Pad2_ 56k
C6 Net-_C6-Pad1_ VSSA C
C19 VSSA Net-_C19-Pad2_ C
C4 /PB4 /OP1O C
R36 GNDA /PB4 1M
R32 GNDA /OP2N 10k
R31 /OP2O /OP2N 90k
C7 Net-_C7-Pad1_ Net-_C7-Pad2_ 27nF
U2 Net-_R15-Pad1_ Net-_R13-Pad1_ /PB1 /U2_CTRL SGM3157
R15 Net-_R15-Pad1_ Net-_R12-Pad2_ 10k
R13 Net-_R13-Pad1_ Net-_R13-Pad2_ 10k
R7 Net-_R6-Pad1_ Net-_R7-Pad2_ GNDA GNDA 1
R6 Net-_R6-Pad1_ Net-_R6-Pad2_ 100
R60 /U19_CTRL Net-_R60-Pad2_ 750
C13 +5V GNDD 220uF
D1 VDD Net-_D1-Pad2_ D
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ GNDD NPN
R46 Net-_D1-Pad2_ Net-_Q1-Pad2_ 10
R43 Net-_Q1-Pad1_ /RL1_CTRL 1k
C42 VDD GNDD C
L3 +5V Net-_L3-Pad2_ Ferrite
L4 GNDD Net-_L4-Pad2_ Ferrite
D4 Net-_C05-Pad2_ GNDPWR D
C36 Net-_C05-Pad2_ GNDPWR C
L1 Net-_C40-Pad1_ Net-_C05-Pad2_ Ferrite
C40 Net-_C40-Pad1_ GNDPWR C
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ GNDD NPN
R1 Net-_D2-Pad2_ Net-_Q2-Pad2_ 10
R44 Net-_Q2-Pad1_ /RL2_CTRL 1k
Q5 Net-_Q5-Pad1_ Net-_D3-Pad2_ GNDD NPN
D3 +5V Net-_D3-Pad2_ D
R16 Net-_Q5-Pad1_ /U1_CTRL 1k
R64 Net-_R64-Pad1_ /MCU_NSS2 470
R65 Net-_R65-Pad1_ /MCU_MOSI 470
R66 Net-_R66-Pad1_ /MCU_SCK 470
R75 Net-_R75-Pad1_ /MCU_NSS1 470
R40 /MCU_MISO GNDPWR 2k
U12 Net-_R59-Pad2_ GNDD /MCU_MISO /VDD_MCU EL357
R59 /MISO Net-_R59-Pad2_ 470
R63 VDD /NSS2 2k
U15 Net-_R64-Pad1_ GNDPWR Net-_R65-Pad1_ GNDPWR /MOSI VDD GNDD /NSS2 ELD207
U16 Net-_R66-Pad1_ GNDPWR Net-_R75-Pad1_ GNDPWR /NSS1 VDD /SCK VDD ELD207
C10 VSSA /VREF_1.25 C
C9 VSSA Net-_C9-Pad2_ C
C21 GNDD GNDA C
D5 GNDD GNDA VDD Diode
R5 Net-_C14-Pad1_ Net-_R5-Pad2_ PTC 1kohm
Q3 Net-_Q3-Pad1_ Net-_Q3-Pad1_ Net-_C14-Pad1_ NPN
Q4 Net-_Q3-Pad1_ Net-_Q3-Pad1_ GNDA NPN
C20 GNDA GNDD C
R29 /MOSI GNDD 2k
R35 /SCK GNDD 2k
R56 /NSS1 GNDD 2k
C41 Net-_C41-Pad1_ Net-_C3-Pad2_ C
D2 VDD Net-_D2-Pad2_ D
R17 Net-_R17-Pad1_ Net-_C14-Pad1_ 100
C30 Net-_C22-Pad1_ VSSA C
U17 VSSA VSSA Net-_C22-Pad1_ Net-_C22-Pad1_ /VREF_1.25 /VREF_1.25 MAX6071AAUT12
R25 Net-_C22-Pad1_ +5V 100
C34 Net-_C22-Pad1_ GNDD C
C22 Net-_C22-Pad1_ GNDD C
R55 GNDA VSSA 330
C8 VSSA GNDD C
.end
